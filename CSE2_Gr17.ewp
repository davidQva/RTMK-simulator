# IAR project CSE2_Gr17.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3X8E Microchip ATSAM3X8E
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CSE2_Gr17.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: C:\Users\ckokk\Desktop\bbbb\CSE2_Gr17\sam3x8-sram_BigHeap.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: at91sam3x8.h context_switching_functions_march_2019.s core_cm3.h core_cmFunc.h core_cmInstr.h cstartup.s exceptions.c exceptions.h kernel_functions.c kernel_functions.h mailbox_functions.c mailbox_functions.h main.c startup_sam3x.c system_sam3x.c system_sam3x.h
